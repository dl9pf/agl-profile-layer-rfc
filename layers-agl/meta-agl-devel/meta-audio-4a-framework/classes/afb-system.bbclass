INSTALL_PREFIX = "${libexecdir}/agl"
