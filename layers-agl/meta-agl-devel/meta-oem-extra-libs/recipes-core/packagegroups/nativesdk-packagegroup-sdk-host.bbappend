RDEPENDS_${PN} =+ "nativesdk-protobuf-dev"
