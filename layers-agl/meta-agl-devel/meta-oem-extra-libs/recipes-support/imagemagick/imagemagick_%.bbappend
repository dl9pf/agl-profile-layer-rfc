DEPENDS_append = " libxml2 libxml2-native"
EXTRA_OECONF_append = " --with-xml"
