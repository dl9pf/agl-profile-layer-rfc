PACKAGECONFIG_remove = "libuv"
