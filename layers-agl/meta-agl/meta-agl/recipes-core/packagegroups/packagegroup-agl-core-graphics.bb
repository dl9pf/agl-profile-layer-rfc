DESCRIPTION = "The minimal set of packages for Graphics Subsystem"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "\
    packagegroup-agl-core-graphics \
    "

ALLOW_EMPTY_${PN} = "1"
