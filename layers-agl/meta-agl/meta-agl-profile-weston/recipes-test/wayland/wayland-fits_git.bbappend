# Updating to latest version is necessary for Weston >= 1.9.0
SRCREV = "f108335e374772ae2818a30ae37fe6fcda81980f"
