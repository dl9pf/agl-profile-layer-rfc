# 2017-09-13 hotfix for harfbuzz build
# Reference https://www.mail-archive.com/yocto@yoctoproject.org/msg36472.html

acpaths = "-I ${STAGING_DATADIR_NATIVE}/aclocal/"
