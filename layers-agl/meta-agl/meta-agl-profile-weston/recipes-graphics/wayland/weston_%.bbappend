EXTRA_OECONF_append = " --enable-ivi-shell"
