do_patch[depends] += "quilt-native:do_populate_sysroot libcap:do_populate_sysroot"
APPLY = "no"
