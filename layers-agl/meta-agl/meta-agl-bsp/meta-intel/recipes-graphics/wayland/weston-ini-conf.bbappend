# Select a different rotation for our default panel.
SRC_URI_remove = "file://hdmi-a-1-270.cfg"
SRC_URI += "file://hdmi-a-1-90.cfg"
