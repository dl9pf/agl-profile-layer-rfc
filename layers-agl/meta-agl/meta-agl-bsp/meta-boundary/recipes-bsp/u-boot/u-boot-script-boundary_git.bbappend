FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
	file://0001-6x_bootscript-Make-bootscript-compatible-with-WIC-an.patch \
"

