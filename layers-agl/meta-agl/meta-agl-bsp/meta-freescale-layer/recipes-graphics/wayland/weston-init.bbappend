WESTONARGS_append_imxgpu3d = " --use-gl"
PACKAGE_ARCH = "${MACHINE_ARCH}"
