# Hotfix for rpm metadata clash with ti-sgx-ddk-um-dev
DIRFILES = "1"
