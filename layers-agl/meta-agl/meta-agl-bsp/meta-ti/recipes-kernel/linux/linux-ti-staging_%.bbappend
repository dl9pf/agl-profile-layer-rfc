require recipes-kernel/linux/linux-dtb.inc

require recipes-kernel/linux/linux-agl.inc
require recipes-kernel/linux/linux-agl-4.9.inc
