KERNEL_MODULE_AUTOLOAD = "mmngrbuf"
