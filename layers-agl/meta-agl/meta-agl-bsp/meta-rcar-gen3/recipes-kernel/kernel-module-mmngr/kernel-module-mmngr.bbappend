KERNEL_MODULE_AUTOLOAD = "mmngr"
