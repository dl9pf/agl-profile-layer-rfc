FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = "file://0003-autoopts-mk-tpl-config.sh-fix-shell-path.patch"
